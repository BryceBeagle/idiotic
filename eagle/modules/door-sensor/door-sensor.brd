# Repository BryceBeagle/idiotic

File README.md:

The purpose of this project was to create a modular Internet of Things (IoT) system to create an interface between DIY
devices and consumer grade products. The end product is focused on the automation of household tasks and behaviors for
these devices, with functionality resembling a combination of IFTTT (If This Then That; used for integration between
different web services) and Tasker (used for automating system actions on a cellphone). Users have the ability to
integrate devices and services from off-the-shelf products and services, as well as third party or homebrewed solutions.

This project provides a design architecture as well as an implementation thereof. The architecture describes a system
that addresses all of the design requirements, while the implementation makes it happen. The implementation provides the
software required to run the system, as well as a set of physical modules that are able to work with it. The modules
include parts lists, PCB schematics, board designs, and embedded software ‒ everything required to create and deploy one
from scratch.

Users are able to configure their system to create collections of tasks, called routines, that are triggered by internal
or external state changes, such as the time transitioning to a predesignated time of the day, or a door being opened.
These routines contain events, or sequences of actions to perform, where each action is an atomic operation for a device
to execute. A routine can contain one or more events, and each event can contain one or more actions to perform. For
example, if a user wants their Philips Hue internet-connected light bulbs to turn on automatically when they open a
specific door, they can create a routine that is run when a predesignated door sensor is activated. Devices send status
updates to a server which listens to the changing values and notifies routines that are subscribed to pieces of data.

The system has a server that handles connections and routes incoming data to device driver instances using a data
control library, henceforth referred to as the controller. The controller manages routines and events in the system as
well as the data structure that holds all of the device instances. Devices, both physical (e.g., a Temperature Sensor)
and cloud-based (e.g., a Google Home), are configured for use by the controller with driver files that express the
capabilities of the hardware or software that they represent. For example, a driver for the Philips Hue smart light
bulbs would express the ability to set and retrieve attributes such as brightness, hue, saturation and on/off state, as
well as behaviors such as dimming and pulsing.

Routines, events, and devices are stored in a configuration, allowing the system to start up preconfigured and ready for
use. Events referenced in routines must have corresponding configuration entries describing them, and devices mentioned
in events must also have drivers that the controller can access and utilize. Storing configurations in non-volatile,
text-based formats allows them to be version controlled, shared, and edited with relative ease.

The software provided with this project, called Idiotic, is an extendable implementation of the system described above.
It is written in Python 3, with the server implemented with the Flask web framework library. Routines, events, and
devices are loaded from JSON configuration files. There are also a small number of PCB devices, designed using Eagle,
that function with the system as a demonstration of functionality.

Developers that wish to integrate their own devices into Idiotic can make use of the server’s client platform agnostic
websocket-based API to integrate their device within the system, using the simple, documented protocol. Creating a
single driver file in a designated directory is all that is required to allow the controller to handle data from, and
make commands to, a new device type. All integrated devices are treated as a first-class citizens within the system.

Furthermore, if the new device is built on an ESP8266 microcontroller platform, there is a provided library that allows
for expedited embedded development and integration within the system. A developer simply needs to extend a template file
to map which functions are correlated with which pieces of data and behaviors. If the new device is unable to utilize
this library, it simply needs to connect to the server over a Websocket and follow a simple communication protocol.

Modules currently in the system:
* Door Open/Close Sensor (already developed but revising is necessary)
* IR blaster/receiver **(hardware only)** - Send IR signals to TV (with ability to record and reproduce remote signals)
* HVAC Thermostat
* Temperature sensor
* Hue Light support
		
Core features of the software  include:
* Ability to utilize and integrate all created PCB modules
* Ability to interface modules together to create useful routines and actions
* Ability to add DIY modules with an easy to use interface

## EAGLE design eagle/modules/door-sensor/door-sensor.brd

Parts:
C1, C2: 1uF; C0805
C3: 100pF; C0805
C4: 10nF; C0805
U$2: MICROUSB609-4613-1-ND; MICROUSB
U$4: AZ1117E; SOT-223
U$6: ESP8266-12E-SMD
U$7: AYZ0202AGRL
U$8: AH9246SC59; SC59

Connections:
3V3: C1.1, C4.2, U$4.P$1 (OUT), U$4.P$2 (OUT), U$6.EN, U$6.GPIO2, U$6.VCC, U$8.VDD
5V: C2.1, U$2.VCC, U$4.P$4 (IN)
COMP->ESP: U$2.TX, U$6.RXD0
DOOR_STATUS: C3.1, U$6.GPIO13, U$8.OUT
ESP->COMP: U$2.RX, U$6.TXD0
GND: C1.2, C2.2, C3.2, C4.1, U$2.GND, U$4.P$3 (GND), U$6.GND, U$6.GPIO15, U$7.1, U$8.GND
PROGRAM: U$6.GPIO0, U$7.2

Notes on the sheet:
MicroUSB
3V3 dropdown
ESP8266
Programming
Hall Effect Sensor

Board: 2 copper layers, 35.1 x 37.3 mm, 9 parts (0 on the bottom side), 7 nets.

## EAGLE design eagle/modules/temp-sensor/temp-sensor.brd

Parts:
C1, C2: 1uF; C0805
JP1: PINHD-1X4; 1X04
R1, R2: 10k; M0805
U$1: MCP9808; MSOP-8
U$2: ESP8266-12E-SMD
U$3: MICROUSB609-4613-1-ND; MICROUSB
U$4: AZ1117E; SOT-223
U$5: AYZ0202AGRL

Connections:
3V3: C1.1, JP1.1, R1.2, R2.2, U$1.P$5 (A2), U$1.P$6 (A1), U$1.P$7 (A0), U$1.P$8 (VDD), U$2.EN, U$2.GPIO2, U$2.VCC, U$4.P$1 (OUT), U$4.P$2 (OUT)
5V: C2.1, U$3.VCC, U$4.P$4 (IN)
COMP->ESP: JP1.2, U$2.RXD0, U$3.TX
ESP->COMP: JP1.3, U$2.TXD0, U$3.RX
GND: C1.2, C2.2, JP1.4, U$1.P$4 (GND), U$2.GND, U$2.GPIO15, U$3.GND, U$4.P$3 (GND), U$5.1
PROGRAM: U$2.GPIO0, U$5.2
SCL: R2.1, U$1.P$2 (SCL), U$2.GPIO12
SDA: R1.1, U$1.P$1 (SDA), U$2.GPIO13

Notes on the sheet:
Temperature Sensor
3V3 dropdown
ESP8266
MicroUSB
Programming

Board: 2 copper layers, 35.1 x 37.3 mm, 10 parts (0 on the bottom side), 8 nets.

## EAGLE design eagle/modules/door-sensor/MicroUSB_SMD.brd

Parts:
C1, C2: 1 µF; 0805
C3: 100 pF; 0805
C4: 10 nF; 0805
U$1: ESP8266-07SMD; ESP8266-07
U$3: AH9246SC59; SC59
U$4: MICROUSB609-4613-1-ND; MICROUSB
U$5: AZ1117E; SOT-223

Connections:
unnamed: C3.1, U$1.GPIO13, U$3.OUT
unnamed: C2.2, C4.1, U$1.EN, U$1.GPIO2, U$1.VCC, U$3.VDD, U$5.P$1 (OUT), U$5.P$2 (OUT)
unnamed: C1.1, U$4.GND (VCC), U$5.P$4 (IN)
unnamed: C1.2, C2.1, C3.2, C4.2, U$1.GND, U$1.GPIO15, U$3.GND, U$4.VCC (GND), U$5.P$3 (GND)
unnamed: U$1.TXD0, U$4.TX
unnamed: U$1.RXD0, U$4.RX
unnamed: U$1.GPIO0, U$4.DEBUG

Notes on the sheet:
3.3 V Regulator
Hall Effect Sensor
MicroUSB Connecter

Board: 2 copper layers, 23.1 x 33.8 mm, 8 parts (0 on the bottom side), 7 nets.

## EAGLE design eagle/modules/thermostat/thermostat.brd

Parts:
C1: 68 nF; C0805
C2: 100 nF; C0805
C3: 1 uF; C0805
C4: 47 uF; UWT_GS
JP1: PINHD-1X4; 1X04
R1, R2, R3: 2k1; M0805
R4: 1k3; M0805
U$1, U$2, U$3: CPC1017N
U$4: ESP8266-12E-SMD
U$5: DS9068SOP-8; SOP-8
U$6: 1N4448W; SOD123
U$7: MB4S; TO-269AA
U$8: SCREWLESS-6AVX9706-6; AVX9706-6
U$9: AYZ0202AGRL

Connections:
3V3: C3.1, JP1.1, U$4.EN, U$4.GPIO2, U$4.VCC, U$5.P$1 (VOUT), U$5.P$2 (SENSE)
24VAC: U$1.P$3 (LOAD1), U$2.P$3 (LOAD1), U$3.P$3 (LOAD1), U$7.P$1 (~1), U$8.P$5 (5), U$8.P$11 (5)
32V: C1.1, C2.1, C4.ANODE (2), U$5.P$8 (VIN), U$7.P$4 (+)
AC_CTRL: U$3.P$4 (LOAD2), U$8.P$3 (3), U$8.P$9 (3)
AC_RELAY: R3.1, U$4.GPIO14
COMP->ESP: JP1.2, U$4.RXD0
ESP->COMP: JP1.3, U$4.TXD0
FAN_CTRL: U$2.P$4 (LOAD2), U$8.P$2 (2), U$8.P$8 (2)
FAN_RELAY: R2.1, U$4.GPIO12
FBR_RET: C1.2, C2.2, C3.2, C4.CATHODE (1), JP1.4, U$1.P$2 (CTRL-), U$2.P$2 (CTRL-), U$3.P$2 (CTRL-), U$4.GND, U$4.GPIO15, U$5.P$5 (SHDN), U$5.P$6 (GND), U$5.P$7 (GND), U$5.P$9 (GND), U$7.P$3 (-), U$9.1
GND: U$7.P$2 (~2), U$8.P$6 (6), U$8.P$12 (6)
HEAT_CTRL: U$1.P$4 (LOAD2), U$8.P$1 (1), U$8.P$7 (1)
HEAT_RELAY: R1.1, U$4.GPIO13, U$6.A
unnamed: R1.2, U$1.P$1 (CTRL+)
unnamed: R2.2, R4.2, U$2.P$1 (CTRL+)
unnamed: R3.2, U$3.P$1 (CTRL+)
unnamed: R4.1, U$6.C
PROGRAM: U$4.GPIO0, U$9.2

Notes on the sheet:
Approx 0.18 uF
Relays
Power Supply
ESP8266
Programming

Board: 2 copper layers, 42.2 x 50.5 mm, 18 parts (0 on the bottom side), 18 nets.

## EAGLE design eagle/modules/breakout-board/breakout-board.brd

Parts:
C1, C2: 1 µF; 0805
SL1, SL2: PINHD-1X9; 1X09
SL3: PINHD-1X5; 1X05
U$1: ESP8266-07HEADER; ESP8266-07-HEADER
U$2: MICROUSB609-4613-1-ND; MICROUSB
U$3: AYZ0202AGRL
U$4: AZ1117E; SOT-223

Connections:
unnamed: C1.1, SL1.1, SL1.6, SL2.1, SL2.7, U$1.EN, U$1.GPIO2, U$1.VCC, U$4.P$1 (OUT), U$4.P$2 (OUT)
unnamed: SL1.2, U$1.GPIO13
unnamed: SL1.3, U$1.GPIO12
unnamed: SL1.4, U$1.GPIO14
unnamed: SL1.5, U$1.GPIO16
unnamed: C2.2, SL1.9, SL3.1, U$2.VCC, U$4.P$4 (IN)
unnamed: SL1.7, U$1.ADC
unnamed: SL1.8, U$1.RST
unnamed: SL2.2, SL3.3, U$1.TXD0, U$2.TX
unnamed: SL2.3, SL3.4, U$1.RXD0, U$2.RX
unnamed: SL2.4, U$1.GPIO5
unnamed: SL2.5, U$1.GPIO4
unnamed: SL2.6, U$1.GPIO0, U$3.2
unnamed: C1.2, C2.1, SL2.8, SL2.9, SL3.2, U$1.GND, U$1.GPIO15, U$2.GND, U$3.1, U$4.P$3 (GND)

Board: 2 copper layers, 25.4 x 33.0 mm, 9 parts (0 on the bottom side), 14 nets.

## EAGLE design eagle/modules/ir/ir.brd

Parts:
C1, C2: 1uF; 0805
C3: 47pF; 0805
D1: LED-IRTSAL6100; LED_5MM
R1: 47; 0805
R2: >11k; 0805
U$1: AX-1838HSHORIZ; AX-1838HS-HORIZ
U$2: ESP8266-07SMD; ESP8266-07
U$3: AYZ0202AGRL
U$4: MICROUSB609-4613-1-ND; MICROUSB
U$5: AZ1117E; SOT-223

Connections:
unnamed: C1.2, U$4.VCC, U$5.P$4 (IN)
unnamed: C1.1, C2.1, C3.2, D1.K (C), R2.1, U$1.GND, U$2.GND, U$2.GPIO15, U$3.3, U$4.GND, U$5.P$3 (GND)
unnamed: R2.2, U$1.OUT, U$2.GPIO12
unnamed: U$2.GPIO0, U$3.2
unnamed: C2.2, C3.1, R1.1, U$2.EN, U$2.VCC, U$5.P$1 (OUT), U$5.P$2 (OUT)
unnamed: U$2.RXD0, U$4.RX
unnamed: U$2.TXD0, U$4.TX
unnamed: D1.A, U$2.GPIO13
unnamed: R1.2, U$1.VCC

Board: 2 copper layers, 30.7 x 34.8 mm, 11 parts (0 on the bottom side), 9 nets.

## EAGLE design eagle/modules/door-sensor/Headers.brd

Board: 2 copper layers, 34.6 x 48.0 mm, 8 parts (0 on the bottom side), 7 nets.

Parts:
C1: .47 uF; C025-050X050
C2: 33 uF; C025-050X050
C3: 100 pF; C025-050X050
C4: 10 nF; C025-050X050
SV1: Header; MA06-1
U$1: ESP8266-07
U$2: LM3940
U$3: AH9246

Connections:
unnamed: C3.1, U$1.GPIO13, U$3.OUT
unnamed: C2.2, C4.1, U$1.EN, U$1.GPIO2, U$1.VCC, U$2.OUT, U$3.VDD
unnamed: C1.1, SV1.6, U$2.IN
unnamed: C1.2, C2.1, C3.2, C4.2, SV1.1, SV1.2, U$1.GND, U$1.GPIO15, U$2.GND, U$3.GND
unnamed: SV1.5, U$1.TXD0
unnamed: SV1.4, U$1.RXD0
unnamed: SV1.3, U$1.GPIO0

## Commit log

2017-03-23 Added ignore for backup copies
2017-03-23 Added LP2980-N (SMD 3.3V Regulator)
2017-03-25 Started aquiring files for SMD switchover
2017-03-26 Moved CAM Files to their own directory
2017-03-26 Renamed directories to be more reflective of contents
2017-07-24 Added board and schematic backups to .gitignore
2017-07-24 Added other form of library backups to .gitignore
2017-07-24 Created Purchase directory to track money spent on project
2017-07-24 Directory for Gerber files
2017-07-24 Moved libraries to Libraries directory
2017-07-24 CAM files now refer to updated directories internally
2017-07-24 Use griefcake IP instead of tubus
2017-07-24 Updated MicroUSB board
2017-07-24 Created a breakout board for debugging purposes
2017-07-30 Rudimentary web server and conditional actions using door sensor
2017-07-30 Renamed door sensor http directory/file to be more descriptive
2017-09-01 Testing more server things. Committing work in preparation for big move
2017-09-01 Directory structure overhaul
2017-09-01 Initial readme
2017-09-02 Added prospectus as README with md formatting
2017-09-05 Fixed pinout of female microusb. Previosly GND/ID was connected to TX instead of NC.
    Fixed width of SMD esp8266. Now using inside holes instead of outside
    ones.
2017-09-20 IR signal recorder
2017-09-21 Added comments to outline what each ignore is for. Added gerber zips
2017-09-21 Updated to use new directory structure Issue #2
2017-09-21 Resized drill holes in header footprints. Also changed to new library for the headers Issue #1
2017-09-25 Removed tGlue from top layer and replaced it with conventional tValue and tName
2017-09-25 Removed glue from export
2017-09-25 Now using relative path names. CAM file can now be used for multiple modules
2017-09-25 Schematic now uses correct tx and rx pins on USB
2017-09-25 Initial board for IR duplication
2017-09-25 Gerber files for IR duplicator board
2017-09-25 Removed wifi libraries from output test
2017-09-25 Switched USB rx and tx pins in schematic
2017-10-06 IR board
2017-10-06 Added IR components
2017-10-26 Simple Flask server. Supports messages from door sensor as well as future messages from API.ai. (Still needs https certs)
2017-11-10 Flask updates Now using Apache with Gunicorn
    Conf files to come soon
2017-11-10 Now uses domain and lights an LED
2017-11-10 Rudimentary Hue testing
2017-11-10 Server config
2017-11-22 Initial attempt at creating shape of devices
2017-11-22 Default attributes and new modules
2017-11-28 Decorators work from subclasses of IotDevice to modify class attributes
    Resolves #3
2017-11-28 Attribute decorators now work
    Resolves #4
2017-11-28 Deleted server.py
    Resolves #5
2017-11-29 Added functionality to hue devices
    The majority of the addition is for group support
    Resolves #7
2017-11-29 Added first implementation of controller
    Uses the IotDevice scheme to do the work. Simple check to make sure that the accessed attributes have been tagged with the @attribute decorator
    Resolves #8
2018-01-15 Some old eagle changes. I don't remember what they were for and diffing is impractical
2018-01-15 Start of routine functionality Created framework for IotRoutine
2018-01-15 Framework for IotEvent
2018-01-15 Framework for IotTrigger
2018-01-15 IotRoutine is now callable by IotTrigger
    may change in the future
2018-01-15 id no longer shadows builtin
2018-01-15 Framework for IotConditional callability (is that a word?)
2018-01-18 Beginning of implementation of IotRoutines. Very much so unfinished
2018-01-25 Temperature sensor module
2018-01-25 Some documentation for temperature sensor
2018-01-25 README for temperature sensor
2018-01-25 Units for temperature reporting
2018-01-25 Symlink to eagle directory for temp-sensor
2018-01-25 Removed old python directory
2018-01-25 Deleted iot_watch as it will be bundled with iot_trigger
2018-01-25 Added on attribute
2018-01-25 Conditionals are functions for now
2018-01-25 get_attr and set_attr now optionally take uuids instead of class type and name
2018-01-25 Attributes can now be subscribed to (untested)
2018-01-25 IotTrigger instances will subscribe to the attribute themselves
2018-01-25 Images for README
2018-01-25 Reduced page size
2018-02-01 Routines can now be built using events, triggers, and conditionals Attributes no longer sublcass property (but are still very similar) This allows me to add subscribers to them
2018-02-01 Send requests to webserver to change attributes of IotDevices. Currently hardcoded to HueDevices
2018-02-02 iot_server README
2018-02-02 Hex literals are apparently disallowed
2018-02-02 README fixes
2018-02-02 Update to use correct import path
2018-02-03 Added python build files to .gitignore
2018-02-04 Initial ESP8266 program to read temperature from MCP9808
2018-02-05 Created library directory and added start of common ESP8266_IoT library
    Currently allows sending single attribute values
2018-02-05 Now sends temperature to server. Uses ESP8266_Iot library
2018-02-05 module_handler no longer takes unused module_class parameter
2018-02-06 CMake test
2018-02-07 Added pullup resistors to PCB and made board part labels for RC components proper
2018-02-08 Switched to platformio build system. Goodbye Arduino IDE!
2018-02-08 More purchase orders
2018-02-08 Updated gitignore to include PlatformIO and CLion build files
2018-02-08 HDMI CEC Whitepaper
2018-02-08 Renamed project to "idiotic"
2018-02-08 Switched to ArduinoJson for creating Json structures. temp-sensor now sends correctly formatted Json
2018-02-08 Added orientation idicator to MCP-9808's package
2018-02-08 Moved label for one of resitors to avoid confusion
2018-02-08 Removed cam job for Windows as it is now agnostic
2018-02-08 Updated CAM file for new Eagle format and gave it a better name
2018-02-08 Removed board outline from Top and Bottom outputs. Added Top-only export
2018-02-08 Removed second board outline
2018-02-11 Renamed arduino directory to embedded as old name was a little misleading
2018-02-12 Added MB4S full bridge rectifier
2018-02-12 Renamed 8-MSOP to MSOP-8
2018-02-12 Added RT9068 3.3V regulator
2018-02-12 Split library up into multiple libraries based on device type
2018-02-12 Renamed LP2980-N package to the SOT-23 package it really is
2018-02-13 Added CPC1017N relay
2018-02-13 Added datasheet link to MB4S
2018-02-14 Added screwless terminals
2018-02-14 Moved symbols on package to tPlace
2018-02-14 (LE)D library
2018-02-14 Connected traces that need internal connections
2018-02-14 Thermostat module
2018-02-14 Removed top only cam as it's not really necessary
2018-02-15 Reimplemented attributes to be much more straightforward
2018-02-15 Moved IdioticDevices into their own directory
2018-02-15 Added information detailing the creation and functionality of IdioticDevice to README
2018-02-15 Updates to README Added __repr__ functions to objects Fixed numerous attribute instance sharing issues
2018-02-17 Attributes now add their names to their class' attribute set Action decorator is now defined outside IdioticDevice
2018-02-18 Devices are now queried for their actions and attributes Actions are now functions wrapped by class instances instead of functions (similar to Attributes)
2018-02-18 Updated idiotic server to use new IdioticDevice attribute get and set style Also removed unused fluff
2018-02-21 Added __init__.py file for easier device importing
2018-02-21 Added passives library with UWT-GS capactior
2018-02-22 Added ESP8266-12E and ESP8266-12E-SMD Renamed device to ESP8266
2018-02-22 Added way of programming boards - header and GPIO0 switch
2018-02-22 Pins were connected to incorrect pad and device was polarized backward. This has been resolved
2018-02-22 Changed drill size to mil
2018-02-22 Added comment for #endif of guard
2018-02-22 Thermostat module initial code init. Includes thermostat class
2018-02-22 Only one active device at a time. Why store state of all three?
2018-03-02 Attempt at using Websockets (currently does not work)
2018-03-11 Socket support
2018-03-11 Fixed fupdate function in IdioticDevice
2018-03-12 Fully working routine with data from live module!
    if temp > 30: light turns on
    if temp < 30: light turns off
2018-03-13 Routine configuration can now happen before devices say hello
2018-03-15 Devices, events, and routines can be loaded from json before server init
2018-03-15 Removed __repr__s as they were more of a nuisance than a help
2018-03-23 Fixed package for DS9068 regulator
2018-03-23 Thermostat can now accept commands
2018-03-23 IdioticModule now parses set commands from server
2018-03-23 Added thermostat test configuration to json files
2018-03-23 Added thermostat to device __init__ file
2018-03-23 Actions now called behaviors, and can now be run using routines
2018-03-23 Added thermostat device
2018-04-06 Removed unused temp2 field
2018-04-10 Added labels to schematics
2018-04-10 Added images of boards and schematics
2018-04-10 Switced SDA and SCL pins for temp sensor to match board. Removed temp2
2018-04-10 Gerber files for temp sensor and thermostat
2018-04-10 .gitignore for embedded directory. Readme
2018-04-10 Fixed erroneous extra parenthesis
2018-04-10 Fixed VCC pin on MCP9808. MCP adr on TS to 0x1F
2018-04-10 door-sensor board V2 using new skills
2018-04-16 Added routine to change brightness of bulb depending on door state.
    Was used in thesis defense demo
2018-04-16 Fixed super() syntax too python3. Also renamed door state to door_open
2018-04-16 Updated door_sensor.cpp to use library
2018-04-16 Removed the model specific '-12E' text on ESP8266 schematic and package
2018-04-16 Removed old door-sensor boards and schematics
2018-04-16 Added lkpf PO
2018-04-16 Removed old, unused files
2018-04-16 Renamed idiotic_devices/ to device_drivers/
2018-04-18 Old purchases orders
2018-04-19 Improved documentation
2018-04-19 Documentation improvements
2018-04-19 server readme improvements
2018-04-19 Expanded on attributes and behaviors in server README
2018-04-19 update json example now formatted to javascript in markdown
2018-04-19 README device driver template improvements
2018-04-19 Improved documentation all around
2018-04-19 Added to README for creating embedded software
2018-04-19 Improved formatting for readme
2018-04-19 Added a bunch of purchase orders
2018-04-19 Readme improvements
2018-04-19 Moved new device driver info to README in device_drivers/
2018-04-19 Removed IR sensor for __init__.py
2018-04-20 Updated images for new board design
2018-04-20 Added WFTPL license
2018-04-20 Updated license text
2018-04-20 Fixed license text
2018-04-20 Updated root readme to be reflective of project
2018-04-20 Added temperature sensor and hue light mentions to root readme
2018-04-20 Increased documentation for Attributes
2018-04-20 Improved documentation for controller
2018-04-20 Improved IdioticDevice attributes' documentation
2018-04-20 Set JSON packet still needs work
2018-04-20 Improved README
2018-04-20 Fixed and updated symlinks in modules/ directory
2018-04-20 Rename LICENSE to LICENSE.txt
2018-04-27 New and updated PRs
2018-04-27 Fixed hue and saturation Attributes. They were using the wrong functions
2018-04-27 Removed overly aggressive try-except block that was masking issues
2018-04-27 Fixed on and room Attributes. They were using the wrong functions
2018-09-19 Added thesis to repo as PDF
2019-02-25 Switch to #pragma onces
2019-02-25 Switch to using WiFiManager instead of hardcoding SSID/Password
2019-03-05 Removed configuration info from json files
2019-03-05 Add requirements.txt for server
2019-03-16 Support ArduinoJson 6
2019-03-16 Added a new Gardenometer device
    - Added the firmware for the new device
    - Added a new device driver

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
